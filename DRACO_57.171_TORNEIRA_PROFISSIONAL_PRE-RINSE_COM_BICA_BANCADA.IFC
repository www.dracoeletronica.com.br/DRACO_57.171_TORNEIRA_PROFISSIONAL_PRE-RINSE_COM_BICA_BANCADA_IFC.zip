Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_57.171_TORNEIRA_PROFISSIONAL_PRE-RINSE_COM_BICA_BANCADA.IFC
Time: 2022-07-01T18:16:32
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
